options:
  parameters:
    generate_options: qt_gui
    id: b210
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f
  id: variable_qtgui_range
  parameters:
    start: '70'
    step: '1'
    stop: '1000'
    value: '600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128*128*100
  states: {}
- name: allan_allan_0
  id: allan_allan
  parameters:
    allan_inc: '1000'
    allan_type: '2'
    input_type: 'True'
    textdisplay: 'False'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: phase->time=phase/(2pif)
    const: 1/2/3.14159/f/1e6
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/256
    decim: '128'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate//256
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/256
    decim: '128'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate//256
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/128/128
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: f*1e6
    center_freq1: f*1e6
    comment: |-
      Synthesizer set to -32 dBm for 
      full scale range measurement
    gain0: '40'
    gain1: '40'
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', allan_allan_0, '0']
- [low_pass_filter_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_arg_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_1, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
