options:
  parameters:
    generate_options: qt_gui
    id: allan_demo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: allan_allan_0
  id: allan_allan
  parameters:
    allan_inc: '1000'
    allan_type: '2'
    textdisplay: 'True'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jmfriedt/sdr/gr-allan/examples/t
    repeat: 'False'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/200
    decim: '100'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: samp_rate/256
    win: window.WIN_HAMMING
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', allan_allan_0, '0']
- [low_pass_filter_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
